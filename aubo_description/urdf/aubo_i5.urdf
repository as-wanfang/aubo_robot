Commit message: update aubo-i5 urdf

File: aubo_description/urdf/aubo_i5.urdf (robot description, URDF)
Before this commit: robot aubo_i5, 8 links, 7 joints
Joints:
- joint shoulder_joint: origin xyz=0 0 0.122 rpy=0 0 3.1416 -> xyz=0 0 0.0985 rpy=0 0 3.1416
